# Keil uVision project project2.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\FWLIB\inc;.\User
  asm include: ..\STM32
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../CMSIS/: system_stm32f10x.c startup_stm32f10x_md.s stm32f10x.h
    ../FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c
    ../FWLIB/inc/: stm32f10x_rcc.h stm32f10x_gpio.h stm32f10x_usart.h
    ./User/: stm32f10x_conf.h
  group New Group
    ./User/: led.c main2.c serial.c led.h serial.h
software components: CMSIS:CORE 4.3.0
